# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\Project;..\STM32F10X_FWLib\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\RELAY;..\HARDWARE\KEY;..\HARDWARE\LCD;..\APP\UI;..\HARDWARE\IIC;..\HARDWARE\BMP180;..\APP\SENSOR;..\APP\ALARM;..\APP\MAX;..\HARDWARE\ONENET;..\APP\WEATHER;..\APP\RS485;..\APP\MODBUS;..\APP\FLASH
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group Project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10X_FWLib
    ../STM32F10X_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c lcd_init.c
    ../HARDWARE/IIC/: iic.c
    ../HARDWARE/BMP180/: bmp180.c
    ../HARDWARE/ONENET/: onenet.c
  group APP
    ../APP/UI/: ui.c
    ../APP/SENSOR/: sensor.c
    ../APP/ALARM/: alarm.c
    ../APP/MAX/: max.c
    ../APP/WEATHER/: weather.c
    ../APP/RS485/: rs485.c
    ../APP/MODBUS/: modbus.c
    ../APP/FLASH/: flash.c
